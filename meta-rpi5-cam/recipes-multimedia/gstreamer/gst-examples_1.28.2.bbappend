require gstreamer-security.inc

# Official 1.28.8 annotated tag, peeled to its immutable source commit.
# The inherited SRC_URI keeps tag=${PV}; BitBake verifies the tag/revision pair.
SRCREV = "1b2a95a1b72787cda146b46df9605b168e5b683b"
