require gstreamer-security.inc

# Verified against the official archive and its .sha256sum sidecar.
SRC_URI[sha256sum] = "51ae53002e3bbe9ed0f2215020c5a248bf0ed41b9d9a2a4e102b8583fedab61c"
