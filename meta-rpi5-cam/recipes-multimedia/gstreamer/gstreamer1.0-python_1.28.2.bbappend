require gstreamer-security.inc

# Verified against the official archive and its .sha256sum sidecar.
SRC_URI[sha256sum] = "6e0d8dd920234b9feeb86003d8f43c1996491f9d8190882329bf56f60a70206e"
