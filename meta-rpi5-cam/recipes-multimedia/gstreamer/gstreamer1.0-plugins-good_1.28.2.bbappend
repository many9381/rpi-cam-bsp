require gstreamer-security.inc

# Verified against the official archive and its .sha256sum sidecar.
SRC_URI[sha256sum] = "a7670ed900d3d03be744d25c1873b239896e9a82ce6d17f8febc6fffbaee9521"
