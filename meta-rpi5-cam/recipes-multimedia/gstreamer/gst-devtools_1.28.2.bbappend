require gstreamer-security.inc

# Verified against the official archive and its .sha256sum sidecar.
SRC_URI[sha256sum] = "a85275f91e421ae55c8ec08779459a3f93f620d2acc25b6e6723ef43573c6ba5"
