require gstreamer-security.inc

# Verified against the official archive and its .sha256sum sidecar.
SRC_URI[sha256sum] = "98ad3d7f8932c495e268708903f1c3388d5f26a0db34727a9f861ee23b724177"
