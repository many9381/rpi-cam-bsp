require gstreamer-security.inc

# Verified against the official archive and its .sha256sum sidecar.
SRC_URI[sha256sum] = "baa8e86985ad6417cc0ad6e7b79ff2884c6779c8b1c7a6240e7121822c86e524"
